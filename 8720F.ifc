Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-12T14:26:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 12 14:26:05 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{0D08EBEB-BDB4-49DE-9759-9C9630CFB5BB}\ifc * Database version: 5507 * Database creation date: Wed Jun 12 14:26:04 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 12 14:26:04 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 12 14:26:04 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 8720F Kitchen faucet, 230/12 V, 8720F:8720F Kitchen faucet, 230/12 V:351528
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 254.2 mm; NominalHeight: 302.3 mm; NominalWidth: 79.6631 mm; Projection: 200 mm
Type - Electrical(Type) - Electrical Connection: 230 / 12 V; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 8720F; ConvergoRefNr: 0087-1906-0047-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basin and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 11/06/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150075551; EMC Directive: 2004/108/EY; EN Standard: EN 15091; LVI Number: 6219107; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4200401; Protection Class: IP 44; RSK Number: 8348045; VVS Number: 704431114
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/8720F; Catalog Drawing URL: http://static.oras.com/catdrw/8720F; Class: Tiptronic, plug transformer; Dimension Drawing URL: http://static.oras.com/dimdrw/8720F; FDV Document URL: http://www.oras.com/datasheet/8720F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/8720F; Group: Kitchen faucets; Long Marketing: Kitchen faucet with swivel spout and aerator. Faucet is opened by pressing gently on top of it, after which the faucet is open for 6 s. (Factory setting) By pressing on top of the faucet for one second, the faucet stays open for one minute. By pressing on top of the faucet for 4 seconds, the faucet goes into cleaning mode and remains closed for 20 seconds. Easy to use temperature control handle which operates also as a flow controller. The faucet can also be opened from the temperature control handle to obtain either hot or cold water without automatic closing. In this case, it closes automatically after five minutes, unless it is manually closed before that. Electrical connection with a plug transformer 230/12 V. Design by Rodrigo Torres.F = with flexible pipes.; Manufacturer: Oras; Market: INT;FIN;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 8720F Kitchen faucet, 230/12 V; Name_en: 8720F Kitchen faucet, 230/12 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 693 x 177 x 92; Package Weight: 3.546 kg; Product Code: 8720F; Product Datasheet: https://www.oras.com/datasheet/8720F/en; Product Family: ALESSI Sense by Oras; Product Image URL: http://static.oras.com/image/8720F; Product URL: http://static.oras.com/8720F; Type Name: 8720F Kitchen faucet, 230/12 V
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Automatic Flush: off (off/12/24/48/72 h); Automatic Flush Period: 30 s (10-600 s); Connection: Flexible Inlet Pipes; Connection Size: G3/8; Flow Rate At 300kPa: 0.00494405 m3/s; Installation and Maintenance: http://static.oras.com/manual/8720F; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 6; Mounting Holes: 1 mounting hole; Number of Shower Sprays: 1 spray; Pipes: Flexible inlet pipe(s); Pressure Loss With Flow 01ls: 155000 Pa; Spare Parts: http://static.oras.com/sp/8720F; Spout Swivel Range: 110° (85° / 60°); Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome/White; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 8720F; Features: Tiptronic, plug transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 8720F; Name: 8720F Kitchen faucet, 230/12 V; ReplacementCost: n/a; Shape: Sculptured; Size: 80x255x300 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 8720F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 8720F Kitchen faucet, 230/12 V
Constraints - FaucetDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.122269 m2; Volume: 0.00612587 m3
Identity Data - Mark: 13
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 8720F: 8720F Kitchen faucet, 230/12 V; Family and Type: 8720F: 8720F Kitchen faucet, 230/12 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 8720F: 8720F Kitchen faucet, 230/12 V; Type Id: 8720F: 8720F Kitchen faucet, 230/12 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
